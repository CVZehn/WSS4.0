# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx +hex
  AfterMake: fromelf --bin !L --output @H.bin
  c flags: Optim=1 uC99=1 uGnu=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,LV_CONF_INCLUDE_SIMPLE
  c include: ..\Bsp\Libraries\inc;..\Bsp\Libraries\CMSIS\Include;..\Bsp\Libraries\CMSIS\Device\Include;..\rt-thread\components\dfs\include;..\rt-thread\components\dfs\filesystems\devfs;..\rt-thread\components\finsh;..\rt-thread\libcpu\arm\cortex-m4;..\rt-thread\include;..\rt-thread\include\libc;..\Project;..\rt-thread\components\drivers\include;..\rt-thread\components\libc\compilers\armlibc;..\rt-thread\components\libc\compilers\common;..\rt-thread\components\libc\pthreads;..\rt-thread\components\libc\time;..\Bsp\Libraries\System;..\Bsp\Drivers\board;..\Bsp\Drivers\usart;..\lvgl\lv_core;..\lvgl\lv_draw;..\lvgl\lv_fonts;..\lvgl\lv_hal;..\lvgl\lv_misc;..\lvgl\lv_objx;..\lvgl\lv_porting;..\lvgl\lv_themes;..\lvgl;..\APP\LCD_TEST;..\APP\LED;..\APP\timer_lvgl_tick;..\Bsp\System\delay;..\Bsp\System\QUEUE;..\Applications\main_task;..\Bsp\Drivers\lcd_fsmc;..\Bsp\Drivers\sram;..\Bsp\Drivers\Bsp_LCD;..\lvgl\lv_my_hal;..\lvgl\demo
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group APP
    ../APP/LCD_TEST/: LCD_TEST.c
    ../APP/LED/: LED.c
  group Applications
    ../Applications/main_task/: main_task.c main.c
  group System
    ../Bsp/System/delay/: delay.c
    ../Bsp/System/QUEUE/: Queue.c
  group Drivers
    ../Bsp/Drivers/board/: board.c
    ../Bsp/Drivers/usart/: usart.c
    ../Bsp/Drivers/Bsp_LCD/: Bsp_LCD.c
  group CORTEX-M4
    ../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Kernel
    ../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group DeviceDrivers
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c
  group CMSIS
    ../Bsp/Libraries/CMSIS/Device/Startup/: startup_stm32f40xx.s
    ../Bsp/Libraries/System/: system_stm32f4xx.c
  group lv_core
    ../lvgl/lv_core/: lv_group.c lv_indev.c lv_lang.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group lv_draw
    ../lvgl/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rbasic.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vbasic.c
  group lv_fonts
    ../lvgl/lv_fonts/: lv_font_builtin.c lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_monospace_8.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group lv_hal
    ../lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_ufs.c
  group lv_objx
    ../lvgl/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group lv_porting
    ../lvgl/lv_porting/: lv_port_disp_templ.c lv_port_fs_templ.c lv_port_indev_templ.c
  group lv_themes
    ../lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lv_my_hal
    ../lvgl/lv_my_hal/: tft.c
  group font
    ../Applications/font/: HZChar.c HZCharPEx.c WRJZY_20.c WRJZY_40.c
  group lvgl_demo
    ../lvgl/demo/: demo.c img_bubble_pattern.c
  group Libraries
    ../Bsp/Libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_rcc.c stm32f4xx_iwdg.c
